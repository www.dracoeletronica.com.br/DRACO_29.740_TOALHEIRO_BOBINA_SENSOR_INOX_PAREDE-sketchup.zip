Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_29.740_TOALHEIRO_BOBINA_SENSOR_INOX_PAREDE.IFC
Time: 2022-06-23T14:33:48
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0
